# IAR project bt_soc_empty_cli.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32ZG28B312F1024IM68 SiliconLaboratories EFR32ZG28B312F1024IM68
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: EFR32ZG28B312F1024IM68=1; SL_CODE_COMPONENT_SYSTEM=system; SL_APP_PROPERTIES=1; BOOTLOADER_APPLOADER=1; SL_BOARD_NAME="BRD4400B"; SL_BOARD_REV="A00"; HARDWARE_BOARD_DEFAULT_RF_BAND_868=1; HARDWARE_BOARD_SUPPORTS_3_RF_BANDS=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_2400=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_868=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_915=1; HFXO_FREQ=39000000; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_DMADRV=dmadrv; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_HAL_SYSRTC=hal_sysrtc; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=1; CLI_INTERFACE=1; RAILAPP_RMR=1; RAILTEST=1; RAIL_PA_AUTO_MODE=1; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_PHY_SELECT=rail_util_ieee802154_phy_select; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_STACK_EVENT=rail_util_ieee802154_stack_event; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SL_CODE_COMPONENT_SE_MANAGER=se_manager; CIRCULAR_QUEUE_USE_LOCAL_CONFIG_HEADER=1; BUFFER_POOL_ALLOCATOR_USE_LOCAL_CONFIG_HEADER=1; RESPONSE_PRINT_USE_LOCAL_CONFIG_HEADER=1; SL_CODE_COMPONENT_CORE=core; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_SLI_CRYPTO=sli_crypto; SLI_RADIOAES_REQUIRES_MASKING=1; SL_CODE_COMPONENT_SLI_PROTOCOL_CRYPTO=sli_protocol_crypto; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\btconf; .; simplicity_sdk_2024.12.1\platform\Device\SiliconLabs\EFR32ZG28\Include; simplicity_sdk_2024.12.1\app\common\util\app_assert; simplicity_sdk_2024.12.1\app\common\util\app_timer; simplicity_sdk_2024.12.1\app\common\util\app_timer\bm; simplicity_sdk_2024.12.1\protocol\bluetooth\inc; simplicity_sdk_2024.12.1\platform\common\inc; simplicity_sdk_2024.12.1\protocol\bluetooth\bgcommon\inc; simplicity_sdk_2024.12.1\protocol\bluetooth\bgstack\ll\inc; simplicity_sdk_2024.12.1\hardware\board\inc; simplicity_sdk_2024.12.1\platform\bootloader; simplicity_sdk_2024.12.1\platform\bootloader\api; simplicity_sdk_2024.12.1\platform\bootloader\core\flash; simplicity_sdk_2024.12.1\platform\service\cli\inc; simplicity_sdk_2024.12.1\platform\service\cli\src; simplicity_sdk_2024.12.1\platform\service\clock_manager\inc; simplicity_sdk_2024.12.1\platform\service\clock_manager\src; simplicity_sdk_2024.12.1\platform\CMSIS\Core\Include; simplicity_sdk_2024.12.1\hardware\driver\configuration_over_swo\inc; simplicity_sdk_2024.12.1\platform\driver\debug\inc; simplicity_sdk_2024.12.1\platform\service\device_manager\inc; simplicity_sdk_2024.12.1\platform\service\device_init\inc; simplicity_sdk_2024.12.1\platform\emdrv\dmadrv\inc; simplicity_sdk_2024.12.1\platform\emdrv\dmadrv\inc\s2_signals; simplicity_sdk_2024.12.1\platform\emdrv\common\inc; simplicity_sdk_2024.12.1\platform\emlib\inc; simplicity_sdk_2024.12.1\app\bluetooth\common\gatt_service_device_information; simplicity_sdk_2024.12.1\platform\driver\gpio\inc; simplicity_sdk_2024.12.1\platform\emdrv\gpiointerrupt\inc; simplicity_sdk_2024.12.1\platform\peripheral\inc; simplicity_sdk_2024.12.1\platform\service\hfxo_manager\inc; simplicity_sdk_2024.12.1\app\bluetooth\common\in_place_ota_dfu; simplicity_sdk_2024.12.1\platform\service\interrupt_manager\inc; simplicity_sdk_2024.12.1\platform\service\interrupt_manager\inc\arm; simplicity_sdk_2024.12.1\platform\service\iostream\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\config; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\config\preset; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\inc; simplicity_sdk_2024.12.1\util\third_party\mbedtls\include; simplicity_sdk_2024.12.1\util\third_party\mbedtls\library; simplicity_sdk_2024.12.1\platform\service\memory_manager\inc; simplicity_sdk_2024.12.1\platform\service\memory_manager\src; simplicity_sdk_2024.12.1\platform\service\memory_manager\profiler\inc; simplicity_sdk_2024.12.1\platform\service\mpu\inc; simplicity_sdk_2024.12.1\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_eusart; simplicity_sdk_2024.12.1\platform\emdrv\nvm3\inc; simplicity_sdk_2024.12.1\platform\emdrv\nvm3\config; simplicity_sdk_2024.12.1\platform\service\power_manager\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_psa_driver\inc; simplicity_sdk_2024.12.1\platform\radio\rail_lib\common; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\ble; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\ieee802154; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\wmbus; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\zwave; simplicity_sdk_2024.12.1\platform\radio\rail_lib\chip\efr32\efr32xg2x; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\sidewalk; simplicity_sdk_2024.12.1\platform\radio\rail_lib\hal; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-auto-mode; simplicity_sdk_2024.12.1\platform\radio\rail_lib\apps\railtest; simplicity_sdk_2024.12.1\platform\radio\rail_lib\apps\railapp; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_ant_div; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_callbacks; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_dma; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_ieee802154; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-conversions; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_power_manager_init; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_protocol; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_pti; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rf_path; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rf_path_switch; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rssi; simplicity_sdk_2024.12.1\platform\security\sl_component\se_manager\inc; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\queue; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\memory_manager; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\response_print; simplicity_sdk_2024.12.1\platform\common\toolchain\inc; simplicity_sdk_2024.12.1\platform\service\system\inc; simplicity_sdk_2024.12.1\platform\service\sleeptimer\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sli_crypto\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_protocol_crypto\src; simplicity_sdk_2024.12.1\platform\security\sl_component\sli_psec_osal\inc; simplicity_sdk_2024.12.1\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bt_soc_empty_cli.s37
  ILINK.IlinkOutputFile: bt_soc_empty_cli.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: bt_soc_empty_cli.ipcf
  group Simplicity Configurator
    ./: app.c app.h app_bm.c bt_soc_empty_cli.slpb main.c readme.md sl_gatt_service_device_information.c
  group Simplicity Configurator/autogen
    autogen/: gatt_db.c gatt_db.h gen.properties linkerfile.icf radioconf_generation_log.json rail_config.c rail_config.h RTE_Components.h sl_application_type.h sl_bluetooth.c sl_bluetooth.h sl_board_default_init.c sl_cli_command_table.c sl_cli_command_table.html sl_cli_handles.h sl_cli_instances.c sl_cli_instances.h sl_component_catalog.h sl_event_handler.c sl_event_handler.h sl_iostream_handles.c sl_iostream_handles.h sl_iostream_init_instances.h sl_iostream_init_usart_instances.c sl_iostream_init_usart_instances.h sl_power_manager_handler.c sl_rail_util_callbacks.c sl_rail_util_ieee802154_phy_select.c sl_rail_util_ieee802154_stack_event.c sl_rail_util_init.c sl_rail_util_init.h sli_cli_hooks.c sli_mbedtls_config_autogen.h sli_mbedtls_config_transform_autogen.h sli_psa_builtin_config_autogen.h sli_psa_config_autogen.h
  group Simplicity Configurator/autogen/.slc_state
    autogen/.slc_state/: .crc_config.crc apack_radioconfig.crc
  group Simplicity Configurator/config
    config/: app_assert_config.h app_properties_config.h btl_interface_cfg.h buffer_pool_allocator_config.h circular_queue_config.h dmadrv_config.h emlib_core_debug_config.h nvm3_default_config.h psa_crypto_config.h response_print_config.h sl_bluetooth_advertiser_config.h sl_bluetooth_config.h sl_bluetooth_connection_config.h sl_board_control_config.h sl_bt_host_adaptation_config.h sl_bt_in_place_ota_dfu_config.h sl_cli_config.h sl_cli_config_inst.h sl_clock_manager_oscillator_config.h sl_clock_manager_tree_config.h sl_core_config.h sl_debug_swo_config.h sl_device_init_dcdc_config.h sl_hfxo_manager_config.h sl_interrupt_manager_s2_config.h sl_iostream_usart_vcom_config.h sl_mbedtls_config.h sl_mbedtls_device_config.h sl_memory_config.h sl_memory_manager_config.h sl_memory_manager_region_config.h sl_mx25_flash_shutdown_eusart_config.h sl_power_manager_config.h sl_rail_test_config.h sl_rail_util_ant_div_config.h sl_rail_util_callbacks_config.h sl_rail_util_dma_config.h sl_rail_util_init_inst0_config.h sl_rail_util_pa_config.h sl_rail_util_power_manager_init_config.h sl_rail_util_protocol_config.h sl_rail_util_pti_config.h sl_rail_util_rf_path_config.h sl_rail_util_rf_path_switch_config.h sl_rail_util_rssi_config.h sl_sleeptimer_config.h
  group Simplicity Configurator/config/btconf
    config/btconf/: gatt_configuration.btconf in_place_ota_dfu.xml
  group Simplicity Configurator/image
    image/: readme_img0.png readme_img1.png readme_img2.png readme_img3.png readme_img4.png
  group Simplicity Configurator/simplicity_sdk_2024.12.1/app/bluetooth/common/gatt_service_device_information
    simplicity_sdk_2024.12.1/app/bluetooth/common/gatt_service_device_information/: sl_gatt_service_device_information.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/app/bluetooth/common/in_place_ota_dfu
    simplicity_sdk_2024.12.1/app/bluetooth/common/in_place_ota_dfu/: sl_bt_in_place_ota_dfu.c sl_bt_in_place_ota_dfu.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/app/common/util/app_assert
    simplicity_sdk_2024.12.1/app/common/util/app_assert/: app_assert.h sl_app_assert.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/app/common/util/app_timer
    simplicity_sdk_2024.12.1/app/common/util/app_timer/: app_timer.h sl_simple_timer.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/app/common/util/app_timer/bm
    simplicity_sdk_2024.12.1/app/common/util/app_timer/bm/: app_timer.c app_timer_internal.h app_timer_types.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/board/inc
    simplicity_sdk_2024.12.1/hardware/board/inc/: sl_board_control.h sl_board_init.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/board/src
    simplicity_sdk_2024.12.1/hardware/board/src/: sl_board_control_gpio.c sl_board_init.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/driver/configuration_over_swo/inc
    simplicity_sdk_2024.12.1/hardware/driver/configuration_over_swo/inc/: sl_cos.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/driver/configuration_over_swo/src
    simplicity_sdk_2024.12.1/hardware/driver/configuration_over_swo/src/: sl_cos.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/driver/mx25_flash_shutdown/inc/sl_mx25_flash_shutdown_eusart
    simplicity_sdk_2024.12.1/hardware/driver/mx25_flash_shutdown/inc/sl_mx25_flash_shutdown_eusart/: sl_mx25_flash_shutdown.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/hardware/driver/mx25_flash_shutdown/src/sl_mx25_flash_shutdown_eusart
    simplicity_sdk_2024.12.1/hardware/driver/mx25_flash_shutdown/src/sl_mx25_flash_shutdown_eusart/: sl_mx25_flash_shutdown.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/bootloader/api
    simplicity_sdk_2024.12.1/platform/bootloader/api/: application_properties.h btl_errorcode.h btl_interface.c btl_interface.h btl_interface_parser.h btl_interface_storage.c btl_interface_storage.h btl_reset_info.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/bootloader/app_properties
    simplicity_sdk_2024.12.1/platform/bootloader/app_properties/: app_properties.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/bootloader/core
    simplicity_sdk_2024.12.1/platform/bootloader/core/: btl_util.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/bootloader/core/flash
    simplicity_sdk_2024.12.1/platform/bootloader/core/flash/: btl_internal_flash.c btl_internal_flash.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/CMSIS/Core/Include
    simplicity_sdk_2024.12.1/platform/CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/common/inc
    simplicity_sdk_2024.12.1/platform/common/inc/: sl_assert.h sl_atomic.h sl_bit.h sl_code_classification.h sl_common.h sl_compiler.h sl_core.h sl_enum.h sl_slist.h sl_status.h sl_string.h sli_code_classification.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/common/src
    simplicity_sdk_2024.12.1/platform/common/src/: sl_assert.c sl_core_cortexm.c sl_slist.c sl_string.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/common/toolchain/inc
    simplicity_sdk_2024.12.1/platform/common/toolchain/inc/: sl_memory.h sl_memory_region.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/Device/SiliconLabs/EFR32ZG28/Include
    simplicity_sdk_2024.12.1/platform/Device/SiliconLabs/EFR32ZG28/Include/: efr32zg28_acmp.h efr32zg28_aes.h efr32zg28_buram.h efr32zg28_burtc.h efr32zg28_cmu.h efr32zg28_dcdc.h efr32zg28_devinfo.h efr32zg28_dma_descriptor.h efr32zg28_dpll.h efr32zg28_emu.h efr32zg28_eusart.h efr32zg28_fsrco.h efr32zg28_gpcrc.h efr32zg28_gpio.h efr32zg28_gpio_port.h efr32zg28_hfrco.h efr32zg28_hfxo.h efr32zg28_i2c.h efr32zg28_iadc.h efr32zg28_icache.h efr32zg28_keyscan.h efr32zg28_lcd.h efr32zg28_lcdrf.h efr32zg28_ldma.h efr32zg28_ldmaxbar.h efr32zg28_ldmaxbar_defines.h efr32zg28_lesense.h efr32zg28_letimer.h efr32zg28_lfrco.h efr32zg28_lfxo.h efr32zg28_mailbox.h efr32zg28_mpahbram.h efr32zg28_msc.h efr32zg28_mvp.h efr32zg28_pcnt.h efr32zg28_pfmxpprf.h efr32zg28_prs.h efr32zg28_prs_signals.h efr32zg28_scratchpad.h efr32zg28_semailbox.h efr32zg28_smu.h efr32zg28_syscfg.h efr32zg28_sysrtc.h efr32zg28_timer.h efr32zg28_ulfrco.h efr32zg28_usart.h efr32zg28_vdac.h efr32zg28_wdog.h efr32zg28b312f1024im68.h em_device.h system_efr32zg28.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/Device/SiliconLabs/EFR32ZG28/Source
    simplicity_sdk_2024.12.1/platform/Device/SiliconLabs/EFR32ZG28/Source/: startup_efr32zg28.c system_efr32zg28.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/driver/debug/inc
    simplicity_sdk_2024.12.1/platform/driver/debug/inc/: sl_debug_swo.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/driver/debug/src
    simplicity_sdk_2024.12.1/platform/driver/debug/src/: sl_debug_swo.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/driver/gpio/inc
    simplicity_sdk_2024.12.1/platform/driver/gpio/inc/: sl_gpio.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/driver/gpio/src
    simplicity_sdk_2024.12.1/platform/driver/gpio/src/: sl_gpio.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/common/inc
    simplicity_sdk_2024.12.1/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/inc
    simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/inc/: dmadrv.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/inc/s2_signals
    simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/inc/s2_signals/: dmadrv_signals.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/src
    simplicity_sdk_2024.12.1/platform/emdrv/dmadrv/src/: dmadrv.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/gpiointerrupt/inc
    simplicity_sdk_2024.12.1/platform/emdrv/gpiointerrupt/inc/: gpiointerrupt.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/gpiointerrupt/src
    simplicity_sdk_2024.12.1/platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/nvm3/config
    simplicity_sdk_2024.12.1/platform/emdrv/nvm3/config/: nvm3_config.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/nvm3/inc
    simplicity_sdk_2024.12.1/platform/emdrv/nvm3/inc/: nvm3.h nvm3_cache.h nvm3_default.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h nvm3_object.h nvm3_page.h nvm3_trace.h nvm3_utils.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emdrv/nvm3/src
    simplicity_sdk_2024.12.1/platform/emdrv/nvm3/src/: nvm3.c nvm3_cache.c nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c nvm3_object.c nvm3_page.c nvm3_utils.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emlib/inc
    simplicity_sdk_2024.12.1/platform/emlib/inc/: em_assert.h em_burtc.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_core_generic.h em_emu.h em_eusart.h em_eusart_compat.h em_gpio.h em_ldma.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_rmu.h em_syscfg.h em_system.h em_system_generic.h em_timer.h em_usart.h em_version.h sli_em_cmu.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/emlib/src
    simplicity_sdk_2024.12.1/platform/emlib/src/: em_burtc.c em_cmu.c em_core.c em_emu.c em_eusart.c em_gpio.c em_ldma.c em_msc.c em_prs.c em_rmu.c em_system.c em_timer.c em_usart.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/peripheral/inc
    simplicity_sdk_2024.12.1/platform/peripheral/inc/: peripheral_sysrtc.h peripheral_sysrtc_compat.h sl_hal_bus.h sl_hal_gpio.h sl_hal_syscfg.h sl_hal_sysrtc.h sl_hal_sysrtc_compat.h sl_hal_system.h sl_hal_system_generic.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/peripheral/src
    simplicity_sdk_2024.12.1/platform/peripheral/src/: sl_hal_gpio.c sl_hal_sysrtc.c sl_hal_system.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railapp
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railapp/: railapp_antenna.c railapp_antenna.h railapp_malloc.c railapp_malloc.h railapp_rmr.c railapp_rmr.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railtest
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railtest/: app_common.h app_hal.c app_main.c app_modes.c app_trx.c app_trx.h mode_helpers.c railtest_helpers.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railtest/app_ci
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/apps/railtest/app_ci/: 154_rx_ci.c address_filter_ci.c autoack_ci.c ble_ci.c channel_hopping_ci.c debug_ci.c error_rate_ci.c gpio_ci.c info_ci.c lbt_ci.c mfm_ci.c packet_ci.c parameter_ci.c radio_config_ci.c script_ci.c timer_ci.c trx_ci.c wmbus_ci.c zwave_ci.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/autogen/librail_release
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/autogen/librail_release/: librail_multiprotocol_efr32xg28_iar_release.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/chip/efr32/efr32xg2x
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/chip/efr32/efr32xg2x/: rail_chip_specific.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/common
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/hal
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/hal/: hal_common.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/hal/efr32
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/hal/efr32/: hal_efr.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-auto-mode
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-auto-mode/: pa_auto_mode.c pa_auto_mode.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-conversions
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_conversions_efr32.h pa_curve_types_efr32.h pa_curves_efr32.c pa_curves_efr32.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-conversions/efr32xg28
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/pa-conversions/efr32xg28/: sl_rail_util_pa_curves_14dbm_868M.h sl_rail_util_pa_curves_14dbm_915M.h sl_rail_util_pa_curves_20dbm_868M.h sl_rail_util_pa_curves_20dbm_915M.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_ant_div
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_ant_div/: sl_rail_util_ant_div.c sl_rail_util_ant_div.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_callbacks
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_callbacks/: sl_rail_util_callbacks.h sli_rail_util_callbacks.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_dma
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_dma/: sl_rail_util_dma.c sl_rail_util_dma.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_ieee802154
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_ieee802154/: sl_rail_util_ieee802154_phy_select.h sl_rail_util_ieee802154_rail_event.c sl_rail_util_ieee802154_stack_event.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_power_manager_init
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_power_manager_init/: sl_rail_util_power_manager_init.c sl_rail_util_power_manager_init.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_protocol
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_protocol/: sl_rail_util_protocol.c sl_rail_util_protocol.h sl_rail_util_protocol_types.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_pti
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_pti/: sl_rail_util_pti.c sl_rail_util_pti.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rf_path
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rf_path/: sl_rail_util_rf_path.c sl_rail_util_rf_path.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rf_path_switch
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rf_path_switch/: sl_rail_util_rf_path_switch.c sl_rail_util_rf_path_switch.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rssi
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/plugin/rail_util_rssi/: sl_rail_util_rssi.c sl_rail_util_rssi.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/ble
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/ble/: rail_ble.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/ieee802154
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/ieee802154/: rail_ieee802154.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/sidewalk
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/sidewalk/: rail_sidewalk.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/wmbus
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/wmbus/: rail_wmbus.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/zwave
    simplicity_sdk_2024.12.1/platform/radio/rail_lib/protocol/zwave/: rail_zwave.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/se_manager/inc
    simplicity_sdk_2024.12.1/platform/security/sl_component/se_manager/inc/: sl_se_manager.h sl_se_manager_attestation.h sl_se_manager_check_config.h sl_se_manager_cipher.h sl_se_manager_config.h sl_se_manager_defines.h sl_se_manager_entropy.h sl_se_manager_hash.h sl_se_manager_internal_keys.h sl_se_manager_key_derivation.h sl_se_manager_key_handling.h sl_se_manager_signature.h sl_se_manager_types.h sl_se_manager_util.h sli_se_manager_features.h sli_se_manager_internal.h sli_se_manager_mailbox.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/se_manager/src
    simplicity_sdk_2024.12.1/platform/security/sl_component/se_manager/src/: sl_se_manager.c sl_se_manager_attestation.c sl_se_manager_cipher.c sl_se_manager_entropy.c sl_se_manager_hash.c sl_se_manager_key_derivation.c sl_se_manager_key_handling.c sl_se_manager_signature.c sl_se_manager_util.c sli_se_manager_mailbox.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/config
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/config/: sli_mbedtls_acceleration.h sli_mbedtls_omnipresent.h sli_psa_acceleration.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/inc
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/inc/: aes_alt.h ccm_alt.h cmac_alt.h ecjpake_alt.h gcm_alt.h se_management.h sha1_alt.h sha256_alt.h sha512_alt.h sl_mbedtls.h sl_psa_crypto.h sl_psa_values.h sli_psa_crypto.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/src
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_mbedtls_support/src/: sl_mbedtls.c sl_psa_crypto.c sli_psa_crypto.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_protocol_crypto/src
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_protocol_crypto/src/: sli_protocol_crypto.h sli_protocol_crypto_radioaes.c sli_radioaes_management.c sli_radioaes_management.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/inc
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/inc/: sli_psa_driver_common.h sli_psa_driver_features.h sli_se_driver_aead.h sli_se_driver_cipher.h sli_se_driver_key_derivation.h sli_se_driver_key_management.h sli_se_driver_mac.h sli_se_opaque_functions.h sli_se_opaque_types.h sli_se_transparent_functions.h sli_se_transparent_types.h sli_se_version_dependencies.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/inc/psa
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/inc/psa/: error.h internal_trusted_storage.h sli_internal_trusted_storage.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/src
    simplicity_sdk_2024.12.1/platform/security/sl_component/sl_psa_driver/src/: sl_psa_its_nvm3.c sli_psa_driver_common.c sli_psa_driver_init.c sli_psa_trng.c sli_se_driver_aead.c sli_se_driver_builtin_keys.c sli_se_driver_cipher.c sli_se_driver_key_derivation.c sli_se_driver_key_management.c sli_se_driver_mac.c sli_se_driver_signature.c sli_se_opaque_driver_aead.c sli_se_opaque_driver_cipher.c sli_se_opaque_driver_mac.c sli_se_opaque_key_derivation.c sli_se_transparent_driver_aead.c sli_se_transparent_driver_cipher.c sli_se_transparent_driver_hash.c sli_se_transparent_driver_mac.c sli_se_transparent_key_derivation.c sli_se_version_dependencies.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sli_crypto/inc
    simplicity_sdk_2024.12.1/platform/security/sl_component/sli_crypto/inc/: sli_crypto.h sli_crypto_s2.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sli_crypto/src
    simplicity_sdk_2024.12.1/platform/security/sl_component/sli_crypto/src/: sl_crypto_s2.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/security/sl_component/sli_psec_osal/inc
    simplicity_sdk_2024.12.1/platform/security/sl_component/sli_psec_osal/inc/: sli_psec_osal.h sli_psec_osal_baremetal.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/cli/inc
    simplicity_sdk_2024.12.1/platform/service/cli/inc/: sl_cli.h sl_cli_arguments.h sl_cli_command.h sl_cli_input.h sl_cli_tokenize.h sl_cli_types.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/cli/src
    simplicity_sdk_2024.12.1/platform/service/cli/src/: sl_cli.c sl_cli_arguments.c sl_cli_command.c sl_cli_input.c sl_cli_io.c sl_cli_tokenize.c sli_cli_arguments.h sli_cli_input.h sli_cli_io.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/clock_manager/inc
    simplicity_sdk_2024.12.1/platform/service/clock_manager/inc/: sl_clock_manager.h sl_clock_manager_init.h sli_clock_manager.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/clock_manager/src
    simplicity_sdk_2024.12.1/platform/service/clock_manager/src/: sl_clock_manager.c sl_clock_manager_hal_s2.c sl_clock_manager_init.c sl_clock_manager_init_hal_s2.c sli_clock_manager_hal.h sli_clock_manager_init_hal.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_init/inc
    simplicity_sdk_2024.12.1/platform/service/device_init/inc/: sl_device_init_dcdc.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_init/src
    simplicity_sdk_2024.12.1/platform/service/device_init/src/: sl_device_init_dcdc_s2.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_manager/clocks
    simplicity_sdk_2024.12.1/platform/service/device_manager/clocks/: sl_device_clock_efr32xg28.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_manager/devices
    simplicity_sdk_2024.12.1/platform/service/device_manager/devices/: sl_device_peripheral_hal_efr32xg28.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_manager/inc
    simplicity_sdk_2024.12.1/platform/service/device_manager/inc/: sl_device_clock.h sl_device_gpio.h sl_device_peripheral.h sl_device_peripheral_types.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/device_manager/src
    simplicity_sdk_2024.12.1/platform/service/device_manager/src/: sl_device_clock.c sl_device_gpio.c sl_device_peripheral.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/hfxo_manager/inc
    simplicity_sdk_2024.12.1/platform/service/hfxo_manager/inc/: sl_hfxo_manager.h sli_hfxo_manager.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/hfxo_manager/src
    simplicity_sdk_2024.12.1/platform/service/hfxo_manager/src/: sl_hfxo_manager.c sl_hfxo_manager_hal_s2.c sli_hfxo_manager_internal.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/interrupt_manager/inc
    simplicity_sdk_2024.12.1/platform/service/interrupt_manager/inc/: sl_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/interrupt_manager/inc/arm
    simplicity_sdk_2024.12.1/platform/service/interrupt_manager/inc/arm/: cmsis_nvic_virtual.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/interrupt_manager/src
    simplicity_sdk_2024.12.1/platform/service/interrupt_manager/src/: sl_interrupt_manager_cortexm.c sli_interrupt_manager.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/iostream/inc
    simplicity_sdk_2024.12.1/platform/service/iostream/inc/: sl_iostream.h sl_iostream_uart.h sl_iostream_usart.h sli_iostream_uart.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/iostream/src
    simplicity_sdk_2024.12.1/platform/service/iostream/src/: sl_iostream.c sl_iostream_retarget_stdio.c sl_iostream_uart.c sl_iostream_usart.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/memory_manager/inc
    simplicity_sdk_2024.12.1/platform/service/memory_manager/inc/: sl_memory_manager.h sl_memory_manager_region.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/memory_manager/profiler/inc
    simplicity_sdk_2024.12.1/platform/service/memory_manager/profiler/inc/: sli_memory_profiler.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/memory_manager/profiler/src
    simplicity_sdk_2024.12.1/platform/service/memory_manager/profiler/src/: sli_memory_profiler_stubs.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/memory_manager/src
    simplicity_sdk_2024.12.1/platform/service/memory_manager/src/: sl_memory_manager.c sl_memory_manager_dynamic_reservation.c sl_memory_manager_pool.c sl_memory_manager_pool_common.c sl_memory_manager_region.c sl_memory_manager_retarget.c sli_memory_manager.h sli_memory_manager_common.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/mpu/inc
    simplicity_sdk_2024.12.1/platform/service/mpu/inc/: sl_mpu.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/mpu/src
    simplicity_sdk_2024.12.1/platform/service/mpu/src/: sl_mpu.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/power_manager/inc
    simplicity_sdk_2024.12.1/platform/service/power_manager/inc/: sl_power_manager.h sl_power_manager_debug.h sli_power_manager.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/power_manager/src/common
    simplicity_sdk_2024.12.1/platform/service/power_manager/src/common/: sl_power_manager_common.c sl_power_manager_em4.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/power_manager/src/sleep_loop
    simplicity_sdk_2024.12.1/platform/service/power_manager/src/sleep_loop/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s2.c sli_power_manager_private.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/sleeptimer/inc
    simplicity_sdk_2024.12.1/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/sleeptimer/src
    simplicity_sdk_2024.12.1/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_burtc.c sl_sleeptimer_hal_sysrtc.c sl_sleeptimer_hal_timer.c sli_sleeptimer_hal.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/system/inc
    simplicity_sdk_2024.12.1/platform/service/system/inc/: sl_system_init.h sl_system_process_action.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/system/src
    simplicity_sdk_2024.12.1/platform/service/system/src/: sl_system_init.c sl_system_process_action.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/udelay/inc
    simplicity_sdk_2024.12.1/platform/service/udelay/inc/: sl_udelay.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/platform/service/udelay/src
    simplicity_sdk_2024.12.1/platform/service/udelay/src/: sl_udelay.c sl_udelay_armv6m_iar.s
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/api
    simplicity_sdk_2024.12.1/protocol/bluetooth/api/: sl_bt.xapi
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/inc
    simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/inc/: sli_bgcommon_debug.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/lib/build/iar/cortex-m33/bgcommon/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/lib/build/iar/cortex-m33/bgcommon/release/: libbgcommon.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/src
    simplicity_sdk_2024.12.1/protocol/bluetooth/bgcommon/src/: sli_bgcommon_debug_efr32.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/bgstack/ll/build/iar/xg28/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/bgstack/ll/build/iar/xg28/release/: liblinklayer.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/bgstack/ll/inc
    simplicity_sdk_2024.12.1/protocol/bluetooth/bgstack/ll/inc/: sl_btctrl_linklayer.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/bgapi_protocol/api3/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/bgapi_protocol/api3/release/: libbgapi_core.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/accept_list/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/accept_list/release/: libble_host_accept_list_stub.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/bgstack/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/bgstack/release/: libble_host.a libbondingdb.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/ble_bgapi/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/ble_bgapi/release/: libble_bgapi.a libble_bgapi_gatt_client.a libble_bgapi_gatt_server.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/hal/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/hal/release/: libble_host_hal_series2.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/hci/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/hci/release/: libble_host_hci.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/system/release
    simplicity_sdk_2024.12.1/protocol/bluetooth/build/iar/cortex-m33/ble_host/system/release/: libble_system.a
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/inc
    simplicity_sdk_2024.12.1/protocol/bluetooth/inc/: sl_apploader_util.h sl_bgapi.h sl_bt_api.h sl_bt_api_compatibility.h sl_bt_ll_config.h sl_bt_stack_config.h sl_bt_stack_init.h sl_bt_types.h sl_bt_version.h sli_bgapi.h sli_bt_accept_list_config.h sli_bt_advertiser_config.h sli_bt_config_defs.h sli_bt_connection_config.h sli_bt_dynamic_gattdb_config.h sli_bt_gattdb_def.h sli_bt_host_adaptation.h sli_bt_l2cap_config.h sli_bt_pawr_advertiser_config.h sli_bt_periodic_advertiser_config.h sli_bt_sync_config.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/src
    simplicity_sdk_2024.12.1/protocol/bluetooth/src/: sl_apploader_util_s2.c sl_bt_stack_init.c sli_bt_accept_list_config.c sli_bt_advertiser_config.c sli_bt_connection_config.c sli_bt_dynamic_gattdb_config.c sli_bt_host_adaptation.c sli_bt_l2cap_config.c sli_bt_pawr_advertiser_config.c sli_bt_periodic_advertiser_config.c sli_bt_sync_config.c
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/memory_manager
    simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/memory_manager/: buffer_pool_allocator.c buffer_pool_allocator.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/queue
    simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/queue/: circular_queue.c circular_queue.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/response_print
    simplicity_sdk_2024.12.1/util/silicon_labs/silabs_core/response_print/: response_print.c response_print.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/third_party/mbedtls/include/mbedtls
    simplicity_sdk_2024.12.1/util/third_party/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/third_party/mbedtls/include/psa
    simplicity_sdk_2024.12.1/util/third_party/mbedtls/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Simplicity Configurator/simplicity_sdk_2024.12.1/util/third_party/mbedtls/library
    simplicity_sdk_2024.12.1/util/third_party/mbedtls/library/: alignment.h base64_internal.h bignum_core.h bignum_internal.h bignum_mod.h bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher_internal.h bn_mul.h check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr.h debug_internal.h ecp_internal_alt.h ecp_invasive.h entropy_poll.h lmots.h md_psa.h md_wrap.h mps_common.h mps_error.h mps_reader.h mps_trace.h padlock.h pk_internal.h pk_wrap.h pkwrite.h platform.c platform_util.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_util.c psa_util_internal.h rsa_alt_helpers.h rsa_internal.h ssl_ciphersuites_internal.h ssl_client.h ssl_debug_helpers.h ssl_misc.h ssl_tls13_invasive.h ssl_tls13_keys.h threading.c x509_internal.h
