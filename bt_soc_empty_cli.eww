<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <!-- Automatically generated by Silicon Labs. -->
    <batchBuild />
    <project>
        <path>$WS_DIR$\bt_soc_empty_cli.ewp</path>
    </project>
</workspace>
