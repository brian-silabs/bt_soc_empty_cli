# IAR project Backup of bt_soc_empty_cli.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32ZG28B312F1024IM68 SiliconLaboratories EFR32ZG28B312F1024IM68
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: EFR32ZG28B312F1024IM68=1; SL_CODE_COMPONENT_SYSTEM=system; SL_APP_PROPERTIES=1; BOOTLOADER_APPLOADER=1; SL_BOARD_NAME="BRD4400B"; SL_BOARD_REV="A00"; HARDWARE_BOARD_DEFAULT_RF_BAND_868=1; HARDWARE_BOARD_SUPPORTS_3_RF_BANDS=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_2400=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_868=1; HARDWARE_BOARD_SUPPORTS_RF_BAND_915=1; HFXO_FREQ=39000000; SL_CODE_COMPONENT_CLOCK_MANAGER=clock_manager; SL_COMPONENT_CATALOG_PRESENT=1; SL_CODE_COMPONENT_DEVICE_PERIPHERAL=device_peripheral; SL_CODE_COMPONENT_DMADRV=dmadrv; SL_CODE_COMPONENT_HAL_COMMON=hal_common; SL_CODE_COMPONENT_HAL_GPIO=hal_gpio; SL_CODE_COMPONENT_HAL_SYSRTC=hal_sysrtc; CMSIS_NVIC_VIRTUAL=1; CMSIS_NVIC_VIRTUAL_HEADER_FILE="cmsis_nvic_virtual.h"; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; SL_CODE_COMPONENT_POWER_MANAGER=power_manager; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=1; CLI_INTERFACE=1; RAILAPP_RMR=1; RAILTEST=1; RAIL_PA_AUTO_MODE=1; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_PHY_SELECT=rail_util_ieee802154_phy_select; SL_CODE_COMPONENT_RAIL_UTIL_IEEE802154_STACK_EVENT=rail_util_ieee802154_stack_event; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; SL_CODE_COMPONENT_SE_MANAGER=se_manager; CIRCULAR_QUEUE_USE_LOCAL_CONFIG_HEADER=1; BUFFER_POOL_ALLOCATOR_USE_LOCAL_CONFIG_HEADER=1; RESPONSE_PRINT_USE_LOCAL_CONFIG_HEADER=1; SL_CODE_COMPONENT_CORE=core; SL_CODE_COMPONENT_SLEEPTIMER=sleeptimer; SL_CODE_COMPONENT_SLI_CRYPTO=sli_crypto; SLI_RADIOAES_REQUIRES_MASKING=1; SL_CODE_COMPONENT_SLI_PROTOCOL_CRYPTO=sli_protocol_crypto; SL_CODE_COMPONENT_PSEC_OSAL=psec_osal
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --cmse
  ICCARM.CCIncludePath2: $FILE_DIR$; autogen; config; config\btconf; .; simplicity_sdk_2024.12.1\platform\Device\SiliconLabs\EFR32ZG28\Include; simplicity_sdk_2024.12.1\app\common\util\app_assert; simplicity_sdk_2024.12.1\app\common\util\app_timer; simplicity_sdk_2024.12.1\app\common\util\app_timer\bm; simplicity_sdk_2024.12.1\protocol\bluetooth\inc; simplicity_sdk_2024.12.1\platform\common\inc; simplicity_sdk_2024.12.1\protocol\bluetooth\bgcommon\inc; simplicity_sdk_2024.12.1\protocol\bluetooth\bgstack\ll\inc; simplicity_sdk_2024.12.1\hardware\board\inc; simplicity_sdk_2024.12.1\platform\bootloader; simplicity_sdk_2024.12.1\platform\bootloader\api; simplicity_sdk_2024.12.1\platform\bootloader\core\flash; simplicity_sdk_2024.12.1\platform\service\cli\inc; simplicity_sdk_2024.12.1\platform\service\cli\src; simplicity_sdk_2024.12.1\platform\service\clock_manager\inc; simplicity_sdk_2024.12.1\platform\service\clock_manager\src; simplicity_sdk_2024.12.1\platform\CMSIS\Core\Include; simplicity_sdk_2024.12.1\hardware\driver\configuration_over_swo\inc; simplicity_sdk_2024.12.1\platform\driver\debug\inc; simplicity_sdk_2024.12.1\platform\service\device_manager\inc; simplicity_sdk_2024.12.1\platform\service\device_init\inc; simplicity_sdk_2024.12.1\platform\emdrv\dmadrv\inc; simplicity_sdk_2024.12.1\platform\emdrv\dmadrv\inc\s2_signals; simplicity_sdk_2024.12.1\platform\emdrv\common\inc; simplicity_sdk_2024.12.1\platform\emlib\inc; simplicity_sdk_2024.12.1\app\bluetooth\common\gatt_service_device_information; simplicity_sdk_2024.12.1\platform\driver\gpio\inc; simplicity_sdk_2024.12.1\platform\emdrv\gpiointerrupt\inc; simplicity_sdk_2024.12.1\platform\peripheral\inc; simplicity_sdk_2024.12.1\platform\service\hfxo_manager\inc; simplicity_sdk_2024.12.1\app\bluetooth\common\in_place_ota_dfu; simplicity_sdk_2024.12.1\platform\service\interrupt_manager\inc; simplicity_sdk_2024.12.1\platform\service\interrupt_manager\inc\arm; simplicity_sdk_2024.12.1\platform\service\iostream\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\config; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\config\preset; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_mbedtls_support\inc; simplicity_sdk_2024.12.1\util\third_party\mbedtls\include; simplicity_sdk_2024.12.1\util\third_party\mbedtls\library; simplicity_sdk_2024.12.1\platform\service\memory_manager\inc; simplicity_sdk_2024.12.1\platform\service\memory_manager\src; simplicity_sdk_2024.12.1\platform\service\memory_manager\profiler\inc; simplicity_sdk_2024.12.1\platform\service\mpu\inc; simplicity_sdk_2024.12.1\hardware\driver\mx25_flash_shutdown\inc\sl_mx25_flash_shutdown_eusart; simplicity_sdk_2024.12.1\platform\emdrv\nvm3\inc; simplicity_sdk_2024.12.1\platform\emdrv\nvm3\config; simplicity_sdk_2024.12.1\platform\service\power_manager\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_psa_driver\inc; simplicity_sdk_2024.12.1\platform\radio\rail_lib\common; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\ble; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\ieee802154; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\wmbus; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\zwave; simplicity_sdk_2024.12.1\platform\radio\rail_lib\chip\efr32\efr32xg2x; simplicity_sdk_2024.12.1\platform\radio\rail_lib\protocol\sidewalk; simplicity_sdk_2024.12.1\platform\radio\rail_lib\hal; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-auto-mode; simplicity_sdk_2024.12.1\platform\radio\rail_lib\apps\railtest; simplicity_sdk_2024.12.1\platform\radio\rail_lib\apps\railapp; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_ant_div; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_callbacks; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_dma; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_ieee802154; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-conversions; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\pa-conversions\efr32xg28; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_power_manager_init; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_protocol; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_pti; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rf_path; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rf_path_switch; simplicity_sdk_2024.12.1\platform\radio\rail_lib\plugin\rail_util_rssi; simplicity_sdk_2024.12.1\platform\security\sl_component\se_manager\inc; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\queue; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\memory_manager; simplicity_sdk_2024.12.1\util\silicon_labs\silabs_core\response_print; simplicity_sdk_2024.12.1\platform\common\toolchain\inc; simplicity_sdk_2024.12.1\platform\service\system\inc; simplicity_sdk_2024.12.1\platform\service\sleeptimer\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sli_crypto\inc; simplicity_sdk_2024.12.1\platform\security\sl_component\sl_protocol_crypto\src; simplicity_sdk_2024.12.1\platform\security\sl_component\sli_psec_osal\inc; simplicity_sdk_2024.12.1\platform\service\udelay\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bt_soc_empty_cli.s37
  ILINK.IlinkOutputFile: bt_soc_empty_cli.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: bt_soc_empty_cli.ipcf
  group Simplicity Configurator/image
    image/: readme_img0.png readme_img1.png readme_img2.png readme_img3.png readme_img4.png
  group Simplicity Configurator/simplicity_sdk_2024.12.1/protocol/bluetooth/api
    simplicity_sdk_2024.12.1/protocol/bluetooth/api/: sl_bt.xapi
